<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\USART3 enable.ewp</path>
  </project>
  <batchBuild />
</workspace>
